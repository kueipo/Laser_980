# Keil uVision project 980_IAP.uvprojx, settings and files
target 980_IAP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 980_IAP +hex
  AfterMake: fromelf --bin !L --output ../BIN/IAP.bin
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../USER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group SFUD
    ../USER/SFUD/inc/: sfud_cfg.h
    ../USER/SFUD/src/: sfud.c sfud_sfdp.c
    ../USER/SFUD/port/: sfud_port.c sfud_demo.c
  group FAL
    ../USER/FAL/porting/: fal_cfg.h fal_flash_sfud_port.c fal_flash_stm32_port.c
    ../USER/FAL/inc/: fal_def.h
    ../USER/FAL/src/: fal.c fal_flash.c fal_partition.c fal_test.c
  group IAP
    ../USER/IAP/Inc/: iap.h
    ../USER/IAP/Src/: iap.c common.c flash_if.c ymodem.c
software components: CMSIS:CORE 4.3.0
