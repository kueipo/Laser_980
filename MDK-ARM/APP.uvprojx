# Keil uVision project APP.uvprojx, settings and files
target APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: APP +hex
  AfterMake: fromelf --bin !L --output ../BIN/IAP.bin
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../User;../User/Config;../User/example;../User/Fonts;../User/GUI_DEV;../User/image;../User/LCD;../User/TOUCH;../User/delay;../User/sys;../sfud/inc;../easyflash/inc;../CRC;../Fal;../easyflash;../
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x200000c0 size 0x2000
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ./: startup_stm32f030x8.s
    ../Src/: system_stm32f0xx.c
  group Fonts
    ../User/Fonts/: font20.c
  group Config
    ../User/Config/: DEV_Config.c
  group sys
    ../User/sys/: sys.c ringbuffer.c ConfigFlag.c
    ../User/: Configure.h
  group SFUD
    ../sfud/inc/: sfud_cfg.h sfud_def.h
    ../sfud/port/: sfud_port.c
    ../sfud/src/: sfud.c sfud_sfdp.c
    ../User/UI/: UI_Img_Map.h
  group fal
    ../Fal/porting/: fal_cfg.h fal_flash_sfud_port.c fal_flash_stm32_port.c
    ../Fal/src/: fal.c fal_flash.c fal_partition.c fal_test.c
  group easyflash
    ../easyflash/inc/: ef_cfg.h
    ../easyflash/port/: ef_port.c
    ../easyflash/src/: ef_utils.c ef_iap.c ef_env.c easyflash.c ef_test.c
  group IAP
    ../IAP/Inc/: iap.h
    ../IAP/Src/: iap.c common.c flash_if.c ymodem.c
  group CRC
    ../CRC/: CRC16.c
  group BSP
    ../User/: Configure.h
    ../User/BSP/: BSP_Common.h BSP_Common.c BSP_GPIO.c BSP_Uart.c BSP_ADC.c BSP_Laser.c
  group App
    ../User/App/: APP_COMMREQ.h APP_Common.h APP_Common.c app.c APP_Operate.c APP_Laser.c
  group Task
    ../User/Task/: Task_Common.h Task_Common.c Task.c Task_PolityHigh.c Task_Console.c Task_FeedBack.c Task_HeartbeatMessage.c Task_FanFB.c
  group Flash_Stm32
    ../User/Stm32Flash/: flash_stm32.h flash_stm32_port.c
software components: CMSIS:CORE 4.3.0
