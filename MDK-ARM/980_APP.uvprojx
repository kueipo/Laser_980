# Keil uVision project 980_APP.uvprojx, settings and files
target 980_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)   CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 980_APP +hex
  AfterMake: fromelf --bin !L --output ../BIN/980_APP_V.bin
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/Config;../User/App;../User/Task;../User/CRC;../User/74HC4051;../User/Fal/inc;../User/easyflash/inc;../User/Fal/porting;../User
  memory RVCT4: ROM 0x8005000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Config
    ../User/Config/: DEV_Config.h DEV_Config.c
  group Sys
    ../User/: history.h
    ../User/Sys/: Delay.c ringbuffer.c ConfigFlag.c Filter.c
  group BSP
    ../User/: Configure.h
    ../User/BSP/: BSP_Common.h BSP_Common.c BSP_GPIO.c BSP_HANDPIECE.c BSP_KEY.c BSP_ADC.c BSP_Frequency.c BSP_DAC.c BSP_Uart.c BSP_SafeLocker.c BSP_LED.c BSP_FAN.c BSP_Buzzer.c
  group App
    ../User/App/: APP_COMMREQ.h APP_Common.h APP_Common.c app.c APP_ACvoltage.c APP_Handpiece.c APP_KEY.c APP_Callback.c APP_SafeLocker.c APP_Operate.c APP_Laser.c APP_LED.c APP_Factory.c APP_Fan.c APP_VoltageDetection.c APP_Mos.c APP_Protect.c APP_Buzzer.c
  group Task
    ../User/Task/: Task_Common.h Task_Common.c Task_DeviceDetection.c Task_HeartbeatMessage.c Task_FanFB.c Task_Console.c Task.c Task_FeedBack.c Task_DeviceRun.c Task_PolityHigh.c Task_FB_Protect.c Task_Protect.c
  group MAX5400
    ../User/MAX5400/: MAX5400.c
  group AD840X
    ../User/AD840X/: AD840X.c
  group CRC
    ../User/CRC/: CRC16.c
  group Fal
    ../User/Fal/porting/: fal_cfg.h fal_flash_stm32_port.c
    ../User/Fal/inc/: fal_def.h
    ../User/Fal/src/: fal.c fal_flash.c fal_partition.c
  group IAP
    ../User/IAP/Inc/: iap.h
    ../User/IAP/Src/: iap.c common.c flash_if.c ymodem.c
  group EasyFlash
    ../User/easyflash/inc/: ef_cfg.h
    ../User/easyflash/src/: easyflash.c ef_env.c ef_iap.c ef_utils.c ef_test.c
    ../User/easyflash/port/: ef_port.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Stm32Flash
    ../User/Stm32Flash/: Stm32_Flash.h Stm32_Flash_port.c
software components: CMSIS:CORE 4.3.0
